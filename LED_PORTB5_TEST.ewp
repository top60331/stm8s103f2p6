# IAR project LED_PORTB5_TEST.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F2P STM8S103F2P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; STM8S_StdPeriph_Driver\src; APP
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LED_PORTB5_TEST.hex
  ILINK.IlinkOutputFile: LED_PORTB5_TEST.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    APP/: main.c stm8s_conf.h
  group STM8S_StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: delay.c stm8s_clk.c stm8s_gpio.c
